<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>ch*1e6+1.25e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-2</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>corr0</key><value>-16</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.5</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>hdelay*100</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>vdelay*1000</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>hdelay</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>(5, 0, 1, 1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vdelay</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>(5, 1, 1,1)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
<param><key>freq</key><value>59.94</value></param>
<param><key>amp</key><value>-7</value></param>
<param><key>offset</key><value>3.5</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>80e3</value></param>
<param><key>width</key><value>80e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>ntsc_crt_f</key>
<param><key>id</key><value>ntsc_crt_f_0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>grid_pos</key><value>(0, 1, 3, 3)</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0.5</value></param>
<param><key>t_scale</key><value>0.000020</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>grid_pos</key><value>(0,0,3,1)</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
<param><key>freq</key><value>15734+hsync</value></param>
<param><key>amp</key><value>7</value></param>
<param><key>offset</key><value>-3.5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>hsync</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10</value></param>
<param><key>max</key><value>+10</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(4,0,1,4)</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>90</value></param>
<param><key>choices</key><value>[90, 96, 102, 170, 176, 182, 188, 192, 198, 204, 210, 216]</value></param>
<param><key>labels</key><value>['1ch', '2ch', '3ch', '4ch', '5ch', '6ch', '7ch', '8ch', '9ch', '10ch', '11ch', '12ch']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>ntsc_crt_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ntsc_crt_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>ntsc_crt_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
